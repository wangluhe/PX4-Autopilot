## src/modules/test_mavlink/Kconfig
```kconfig
menuconfig MODULES_TEST_MAVLINK
	bool "test_mavlink"
	default n
	---help---
		Enable support for test_mavlink
```
